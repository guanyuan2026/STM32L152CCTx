# Keil uVision project demo_for_c20.uvprojx, settings and files
target demo_for_c20 (ARM-ADS)
  device: STM32L152CC STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x803FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: demo_for_c20 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L152xC
  c include: ../Core/Inc;       ../Drivers/STM32L1xx_HAL_Driver/Inc;       ../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy;       ../Drivers/CMSIS/Device/ST/STM32L1xx/Include;       ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32l152xc.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c spi.c usart.c stm32l1xx_it.c stm32l1xx_hal_msp.c W25QXX.c
  group Drivers/STM32L1xx_HAL_Driver
    ../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_adc.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_dma.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_cortex.c stm32l1xx_hal_exti.c stm32l1xx_hal_iwdg.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_spi.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l1xx.c
software components: CMSIS:CORE 4.3.0
